# Keil uVision project servo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: servo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: ADC.c ADC.h data_types.h GPIO_ADC.c GPIO_ADC.h HW_ADC.h HW_gpio.h HW_PWMGEN.h PWMG.c PWMG.h startup_TM4C123.s SysCtrl.c SysCtrl.h main.c GPIO_NOKIA5110.c GPIO_NOKIA5110.h GPIO_SPI.c GPIO_SPI.h HW_SPI.h NOKIA5110.c NOKIA5110.h SPI.c SPI.h
software components: CMSIS:CORE 5.0.2
